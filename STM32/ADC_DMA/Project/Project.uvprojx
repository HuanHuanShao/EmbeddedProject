# Keil uVision project Project.uvprojx, settings and files
target ADC_DMA (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32H743VGHx STMicroelectronics
  pack: Keil.STM32H7xx_DFP.2.2.0
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x24000000,0x00080000) IROM(0x08000000,0x00100000) CPUTYPE("Cortex-M7") FPU3(DFPU) CLOCK(12000000) ELITTLE
  output: Project +hex
  c flags: Optim=3 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER, STM32H743xx, __DCACHE_PRESENT=1, __FPU_PRESENT=1, __CC_ARM, ARM_MATH_CM7, ARM_MATH_MATRIX_CHECK, ARM_MATH_ROUNDING
  c include: ..\App;..\Cpu;..\Driver;..\Dsp;..\Main;..\Net;..\RF_Cfg_Chart;..\RF_Cfg;..\SDK\CMSIS\Include;..\SDK\CMSIS\Device\ST\STM32H7xx\Include;..\SDK\CMSIS\Device\ST\STM32H7xx\Source\Templates;..\SDK\STM32H7xx_HAL_Driver\Inc;..\SDK\STM32H7xx_HAL_Driver\Inc\Legacy;..\SDK\CMSIS\DSP\Include
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x24000000 size 0x80000
  group Cpu
    ../Cpu/: system_stm32h7xx.c stm32h7xx_it.c startup_stm32h743xx.s
  group Driver
    ../Driver/: driver_adc.c driver_gpio.c driver_dma.c
  group Main
    ../Main/: main.c system_clk.c tim2_delay.c
  group SDK
    ../SDK/STM32H7xx_HAL_Driver/Src/: stm32h7xx_hal.c stm32h7xx_hal_adc.c stm32h7xx_hal_adc_ex.c stm32h7xx_hal_cortex.c stm32h7xx_hal_dma.c stm32h7xx_hal_dma_ex.c stm32h7xx_hal_exti.c stm32h7xx_hal_gpio.c stm32h7xx_hal_pwr.c stm32h7xx_hal_pwr_ex.c stm32h7xx_hal_qspi.c stm32h7xx_hal_rcc.c stm32h7xx_hal_rcc_ex.c stm32h7xx_hal_spi.c stm32h7xx_hal_spi_ex.c stm32h7xx_hal_wwdg.c stm32h7xx_hal_mdma.c stm32h7xx_hal_tim.c stm32h7xx_hal_tim_ex.c
software components: CMSIS:CORE 5.1.2, CMSIS:DSP 1.7.0
